# IAR project stm32workspace.ewp, settings and files
configuration stm32workspace (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 5
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../App/Inc; ../Board/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32workspace.hex
  ILINK.IlinkOutputFile: stm32workspace.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c ssd1306_simple.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/App
    ../App/Src/: xbox_protocol.c motor.c ultrasonic.c safety_controller.c diagnostics.c control_system.c
  group Application/User/Board
    ../Board/Src/: board_runtime.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
